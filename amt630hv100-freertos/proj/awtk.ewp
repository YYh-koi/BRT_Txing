# IAR project awtk.ewp, settings and files
configuration library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: AWTK; USE_TTF_FONT_DATA_CACHE; ENABLE_MEM_LEAK_CHECK; PNG_NO_CONFIG_H; WITH_LIBPNG_IMAGE; VG_DRAW_IMAGE_DIRECT; VG_DRAW_IMAGE_REPEAT; DIRTY_RECTS_CLIP_SUPPORT; AMT630HV100; WITH_BITMAP_BGR565; WITH_FB_BGR565=1; HMI_AWTK; XM_HMI_HOST; FREERTOS=1; POWERPAC; USE_GUI_MAIN; LCD=VG_GPU; NANOVG_BACKEND=VG; WITH_ASSET_LOADER; WITH_FS_RES; WITH_ASSET_LOADER_ZIP; WITH_IME_PINYIN; __WITH_IME_SPINYIN; __WITH_IME_NULL; STBTT_STATIC; STB_IMAGE_STATIC; WITH_STB_IMAGE; WITH_VGCANVAS; WITH_UNICODE_BREAK; WITH_DESKTOP_STYLE; HAS_PTHREAD=1; HAVE_CONFIG_H; HAS_GET_TIME_US64; WITH_DATA_READER_WRITER; WITH_VG_GPU; WITH_FT_FONT; WITH_NANOVG_VG; XM_HMI_HOST; LZ4_DISABLE_DEPRECATE_WARNINGS; MINIZ_NO_STDIO; MINIZ_NO_TIME; __inline=inline; HAVE_CLOCK_GETTIME; NANOVG_NO_STDIO; VGCANVAS_DIRTY_RECTS_SUPPORT; __WITH_G2D
  ICCARM.CCDiagSuppress: Pa050,Pe301,Pa089,Pe177
  ICCARM.CCIncludePath2: ..\lib\awtk\awtk\src; ..\lib\awtk\awtk\3rd; ..\lib\awtk\awtk\src\ext_widgets; ..\lib\awtk\awtk\3rd\pixman; ..\lib\awtk\awtk\3rd\agge; ..\lib\awtk\awtk\3rd\agg\include; ..\lib\awtk\awtk\3rd\cjson; ..\lib\awtk\awtk\3rd\nanovg; ..\lib\awtk\awtk\3rd\nanovg\base; ..\lib\awtk\awtk\3rd\gpinyin\include;; ..\lib\awtk\awtk\3rd\libunibreak; ..\lib\awtk\awtk\3rd\gpinyin\include\; ..\lib\awtk\awtk\3rd\gtest\googletest; ..\lib\awtk\awtk\3rd\gtest\googletest\include; ..\lib\awtk\awtk\3rd\xm\include; ..\lib\awtk\awtk\3rd\xm\include\vg; ..\lib\awtk\awtk\3rd\zlib; ..\lib\awtk\awtk\3rd\libpng; ..\lib\awtk\awtk\src\vgcanvas; ..\lib\awtk\awtk\tools; ..\..; ..\; ..\FreeRTOS\Source\portable\; ..\lib\lib_rtos\; ..\FreeRTOS\Source\include; ..\FreeRTOS-Plus\FreeRTOS-FAT\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX\; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private\; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\; ..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable\; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: awtk.out
  group awtk/3rd/cjson
    ../lib/awtk/awtk/3rd/cjson/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h
  group awtk/3rd/gpinyin
    ../lib/awtk/awtk/3rd/gpinyin/src/: dictlist.cpp dicttrie.cpp lpicache.cpp matrixsearch.cpp mystdlib.cpp ngram.cpp pinyinime.cpp searchutility.cpp spellingtrie.cpp splparser.cpp utf16char.cpp
  group awtk/3rd/libpng
    ../lib/awtk/awtk/3rd/libpng/: png.c png.h pngconf.h pngdebug.h pngerror.c pngget.c pnginfo.h pnglibconf.h pngmem.c pngpread.c pngpriv.h pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngstruct.h pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c
  group awtk/3rd/libunibreak
    ../lib/awtk/awtk/3rd/libunibreak/: emojidef.c emojidef.h graphemebreak.c graphemebreak.h graphemebreakdef.h linebreak.c linebreak.h linebreakdata.c linebreakdef.c linebreakdef.h unibreakbase.c unibreakbase.h unibreakdef.c unibreakdef.h wordbreak.c wordbreak.h wordbreakdef.h
  group awtk/3rd/lz4
    ../lib/awtk/awtk/3rd/lz4/: lz4.c lz4.h lz4frame.c lz4frame.h lz4frame_static.h lz4hc.c lz4hc.h xxhash.c xxhash.h
  group awtk/3rd/miniz
    ../lib/awtk/awtk/3rd/miniz/: miniz.c miniz.h miniz_common.h miniz_export.h miniz_tdef.c miniz_tdef.h miniz_tinfl.c miniz_tinfl.h miniz_zip.c miniz_zip.h
  group awtk/3rd/nanovg
    ../lib/awtk/awtk/3rd/nanovg/base/: fontstash.h nanovg.c nanovg.h stb_image.h stb_truetype.h
  group awtk/3rd/pixman
    ../lib/awtk/awtk/3rd/pixman/pixman/: pixman.c pixman.h
  group awtk/3rd/xm/src
    ../lib/awtk/awtk/3rd/xm/src/: main_loop_xm.c native_window_xm.c native_window_xm.h vgcanvas_nanovg_vg.c xm_hmi_host.c
  group awtk/3rd/zlib
    ../lib/awtk/awtk/3rd/zlib/: adler32.c compress.c crc32.c crc32.h deflate.c deflate.h gzguts.h infback.c inffast.c inffast.h inffixed.h inflate.c inflate.h inftrees.c inftrees.h trees.c trees.h uncompr.c zconf.h zlib.h zutil.c zutil.h
  group awtk/demos
    ../lib/awtk/awtk/demos/: assets.c assets.h demo1_app.c demo_animator_app.c demo_basic.c demo_desktop.c demo_thread_app.c demo_ui_app.c demo_vg_app.c
  group awtk/src
    ../lib/awtk/awtk/src/: awtk.h awtk_base.h awtk_ext_widgets.h awtk_global.c awtk_global.h awtk_tkc.h awtk_widgets.h
  group awtk/src/base
    ../lib/awtk/awtk/src/base/: asset_loader.c asset_loader.h asset_loader_default.c asset_loader_default.h asset_loader_zip.c asset_loader_zip.h assets_manager.c assets_manager.h awtk_config_sample.h bidi.c bidi.h bitmap.c bitmap.h canvas.c canvas.h canvas_offline.h children_layouter.c children_layouter.h children_layouter_factory.c children_layouter_factory.h clip_board.c clip_board.h data_reader_asset.c data_reader_asset.h date_time_format.c date_time_format.h dialog.c dialog.h dialog_highlighter.c dialog_highlighter.h dialog_highlighter_factory.c dialog_highlighter_factory.h enums.c enums.h event_queue.c event_queue.h event_recorder_player.c event_recorder_player.h events.c events.h font.c font.h font_loader.c font_loader.h font_manager.c font_manager.h g2d.h glyph_cache.c glyph_cache.h graphic_buffer.c graphic_buffer.h hscrollable.c hscrollable.h idle.c idle.h image_base.c image_base.h image_loader.c image_loader.h image_manager.c image_manager.h input_device_status.c input_device_status.h input_engine.c input_engine.h input_method.c input_method.h keys.h layout.c layout.h layout_def.h lcd.c lcd.h lcd_profile.c lcd_profile.h line_break.c line_break.h locale_info.c locale_info.h main_loop.c main_loop.h native_window.c native_window.h pixel.h pixel_pack_unpack.h self_layouter.c self_layouter.h self_layouter_factory.c self_layouter_factory.h shortcut.c shortcut.h style.c style.h style_const.c style_const.h style_factory.c style_factory.h style_mutable.c style_mutable.h suggest_words.c suggest_words.h system_info.c system_info.h text_edit.c text_edit.h theme.c theme.h timer.c timer.h types_def.h ui_builder.c ui_builder.h ui_feedback.c ui_feedback.h ui_loader.c ui_loader.h velocity.c velocity.h vgcanvas.c vgcanvas.h widget.c widget.h widget_animator.c widget_animator.h widget_animator_factory.h widget_animator_factory_null.c widget_animator_manager.c widget_animator_manager.h widget_consts.h widget_factory.c widget_factory.h widget_vtable.c widget_vtable.h window.c window.h window_animator.c window_animator.h window_animator_factory.c window_animator_factory.h window_base.c window_base.h window_manager.c window_manager.h
  group awtk/src/blend
    ../lib/awtk/awtk/src/blend/: blend_image_bgr565_bgr565.c blend_image_bgr565_bgr565.h blend_image_bgr565_bgra8888.c blend_image_bgr565_bgra8888.h blend_image_bgr565_rgb565.c blend_image_bgr565_rgb565.h blend_image_bgr565_rgba8888.c blend_image_bgr565_rgba8888.h blend_image_bgr888_bgr565.c blend_image_bgr888_bgr565.h blend_image_bgr888_bgr888.c blend_image_bgr888_bgr888.h blend_image_bgr888_bgra8888.c blend_image_bgr888_bgra8888.h blend_image_bgr888_rgb565.c blend_image_bgr888_rgb565.h blend_image_bgr888_rgba8888.c blend_image_bgr888_rgba8888.h blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgr565.h blend_image_bgra8888_bgra8888.c blend_image_bgra8888_bgra8888.h blend_image_bgra8888_rgb565.c blend_image_bgra8888_rgb565.h blend_image_bgra8888_rgba8888.c blend_image_bgra8888_rgba8888.h blend_image_rgb565_bgr565.c blend_image_rgb565_bgr565.h blend_image_rgb565_bgra8888.c blend_image_rgb565_bgra8888.h blend_image_rgb565_rgb565.c blend_image_rgb565_rgb565.h blend_image_rgb565_rgba8888.c blend_image_rgb565_rgba8888.h blend_image_rgb888_bgr565.c blend_image_rgb888_bgr565.h blend_image_rgb888_bgra8888.c blend_image_rgb888_bgra8888.h blend_image_rgb888_rgb565.c blend_image_rgb888_rgb565.h blend_image_rgb888_rgb888.c blend_image_rgb888_rgb888.h blend_image_rgb888_rgba8888.c blend_image_rgb888_rgba8888.h blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgr565.h blend_image_rgba8888_bgra8888.c blend_image_rgba8888_bgra8888.h blend_image_rgba8888_rgb565.c blend_image_rgba8888_rgb565.h blend_image_rgba8888_rgba8888.c blend_image_rgba8888_rgba8888.h fill_image_abgr8888.c fill_image_abgr8888.h fill_image_argb8888.c fill_image_argb8888.h fill_image_bgr565.c fill_image_bgr565.h fill_image_bgr888.c fill_image_bgr888.h fill_image_bgra8888.c fill_image_bgra8888.h fill_image_rgb565.c fill_image_rgb565.h fill_image_rgb888.c fill_image_rgb888.h fill_image_rgba8888.c fill_image_rgba8888.h gen.sh image_g2d.c image_g2d.h rotate_image_bgr565.c rotate_image_bgr565.h rotate_image_bgr888.c rotate_image_bgr888.h rotate_image_bgra8888.c rotate_image_bgra8888.h rotate_image_rgb565.c rotate_image_rgb565.h rotate_image_rgb888.c rotate_image_rgb888.h rotate_image_rgba8888.c rotate_image_rgba8888.h soft_g2d.c soft_g2d.h stm32_g2d.c
  group awtk/src/charset
    ../lib/awtk/awtk/src/charset/: encoding.c encoding.h
  group awtk/src/clip_board
    ../lib/awtk/awtk/src/clip_board/: clip_board_default.c clip_board_default.h
  group awtk/src/compressors
    ../lib/awtk/awtk/src/compressors/: compressor_miniz.c compressor_miniz.h
  group awtk/src/conf_io
    ../lib/awtk/awtk/src/conf_io/: app_conf.c app_conf.h app_conf_init.c app_conf_init.h app_conf_init_ini.c app_conf_init_ini.h app_conf_init_json.c app_conf_init_json.h app_conf_init_ubjson.c app_conf_init_ubjson.h conf_ini.c conf_ini.h conf_json.c conf_json.h conf_node.c conf_node.h conf_obj.c conf_obj.h conf_ubjson.c conf_ubjson.h
  group awtk/src/dialog_highlighters
    ../lib/awtk/awtk/src/dialog_highlighters/: dialog_highlighter_builtins.c dialog_highlighter_builtins.h dialog_highlighter_default.c dialog_highlighter_default.h
  group awtk/src/ext_widgets
    ../lib/awtk/awtk/src/ext_widgets/: ext_widgets.c ext_widgets.h
  group awtk/src/ext_widgets/canvas_widget
    ../lib/awtk/awtk/src/ext_widgets/canvas_widget/: canvas_widget.c canvas_widget.h
  group awtk/src/ext_widgets/color_picker
    ../lib/awtk/awtk/src/ext_widgets/color_picker/: color_component.c color_component.h color_picker.c color_picker.h color_picker_const.h rgb_and_hsv.c rgb_and_hsv.h
  group awtk/src/ext_widgets/combo_box_ex
    ../lib/awtk/awtk/src/ext_widgets/combo_box_ex/: combo_box_ex.c combo_box_ex.h
  group awtk/src/ext_widgets/features
    ../lib/awtk/awtk/src/ext_widgets/features/: draggable.c draggable.h
  group awtk/src/ext_widgets/file_browser
    ../lib/awtk/awtk/src/ext_widgets/file_browser/: file_browser.c file_browser.h file_browser_view.c file_browser_view.h file_chooser.c file_chooser.h
  group awtk/src/ext_widgets/gif_image
    ../lib/awtk/awtk/src/ext_widgets/gif_image/: gif_image.c gif_image.h
  group awtk/src/ext_widgets/guage
    ../lib/awtk/awtk/src/ext_widgets/gauge/: gauge.c gauge.h gauge_pointer.c gauge_pointer.h
  group awtk/src/ext_widgets/image_animation
    ../lib/awtk/awtk/src/ext_widgets/image_animation/: image_animation.c image_animation.h
  group awtk/src/ext_widgets/image_value
    ../lib/awtk/awtk/src/ext_widgets/image_value/: image_value.c image_value.h
  group awtk/src/ext_widgets/keyboard
    ../lib/awtk/awtk/src/ext_widgets/keyboard/: candidates.c candidates.h keyboard.c keyboard.h lang_indicator.c lang_indicator.h
  group awtk/src/ext_widgets/mledit
    ../lib/awtk/awtk/src/ext_widgets/mledit/: line_number.c line_number.h mledit.c mledit.h
  group awtk/src/ext_widgets/mutable_image
    ../lib/awtk/awtk/src/ext_widgets/mutable_image/: mutable_image.c mutable_image.h
  group awtk/src/ext_widgets/progress_circle
    ../lib/awtk/awtk/src/ext_widgets/progress_circle/: progress_circle.c progress_circle.h
  group awtk/src/ext_widgets/rich_text
    ../lib/awtk/awtk/src/ext_widgets/rich_text/: rich_text.c rich_text.h rich_text_node.c rich_text_node.h rich_text_parser.c rich_text_parser.h rich_text_render_node.c rich_text_render_node.h rich_text_view.c rich_text_view.h
  group awtk/src/ext_widgets/scroll_label
    ../lib/awtk/awtk/src/ext_widgets/scroll_label/: hscroll_label.c hscroll_label.h
  group awtk/src/ext_widgets/scroll_view
    ../lib/awtk/awtk/src/ext_widgets/scroll_view/: children_layouter_list_view.c children_layouter_list_view.h list_item.c list_item.h list_view.c list_view.h list_view_h.c list_view_h.h scroll_bar.c scroll_bar.h scroll_view.c scroll_view.h
  group awtk/src/ext_widgets/slide_menu
    ../lib/awtk/awtk/src/ext_widgets/slide_menu/: slide_menu.c slide_menu.h
  group awtk/src/ext_widgets/slide_view
    ../lib/awtk/awtk/src/ext_widgets/slide_view/: slide_indicator.c slide_indicator.h slide_view.c slide_view.h
  group awtk/src/ext_widgets/svg_image
    ../lib/awtk/awtk/src/ext_widgets/svg_image/: svg_image.c svg_image.h
  group awtk/src/ext_widgets/switch
    ../lib/awtk/awtk/src/ext_widgets/switch/: switch.c switch.h
  group awtk/src/ext_widgets/text_selector
    ../lib/awtk/awtk/src/ext_widgets/text_selector/: text_selector.c text_selector.h
  group awtk/src/ext_widgets/time_clock
    ../lib/awtk/awtk/src/ext_widgets/time_clock/: time_clock.c time_clock.h
  group awtk/src/ext_widgets/vpage
    ../lib/awtk/awtk/src/ext_widgets/vpage/: vpage.c vpage.h
  group awtk/src/font_loader
    ../lib/awtk/awtk/src/font_loader/: font_loader_bitmap.c font_loader_bitmap.h font_loader_ft.c font_loader_ft.h font_loader_stb.c font_loader_stb.h font_loader_truetype.h
  group awtk/src/fscript_ext
    ../lib/awtk/awtk/src/fscript_ext/: fscript_app_conf.c fscript_app_conf.h fscript_array.c fscript_array.h fscript_bits.c fscript_bits.h fscript_crc.c fscript_crc.h fscript_date_time.c fscript_date_time.h fscript_endian.c fscript_endian.h fscript_ext.c fscript_ext.h fscript_fs.c fscript_fs.h fscript_iostream.c fscript_iostream.h fscript_iostream_file.c fscript_iostream_file.h fscript_iostream_inet.c fscript_iostream_inet.h fscript_iostream_serial.c fscript_iostream_serial.h fscript_istream.c fscript_istream.h fscript_json.c fscript_json.h fscript_math.c fscript_math.h fscript_object.c fscript_object.h fscript_ostream.c fscript_ostream.h fscript_rbuffer.c fscript_rbuffer.h fscript_typed_array.c fscript_typed_array.h fscript_utils.c fscript_utils.h fscript_wbuffer.c fscript_wbuffer.h fscript_widget.c fscript_widget.h
  group awtk/src/graphic_buffer
    ../lib/awtk/awtk/src/graphic_buffer/: graphic_buffer_default.c
  group awtk/src/image_loader
    ../lib/awtk/awtk/src/image_loader/: image_loader_libpng.c image_loader_libpng.h image_loader_stb.c image_loader_stb.h
  group awtk/src/input_engines
    ../lib/awtk/awtk/src/input_engines/: ime_utils.c ime_utils.h input_engine_null.c input_engine_null.h input_engine_pinyin.cpp input_engine_pinyin.h input_engine_spinyin.c input_engine_t9.c input_engine_t9ext.c
  group awtk/src/input_methods
    ../lib/awtk/awtk/src/input_methods/: input_method_creator.c
  group awtk/src/layouters
    ../lib/awtk/awtk/src/layouters/: children_layouter_builtins.c children_layouter_builtins.h children_layouter_default.c children_layouter_default.h children_layouter_parser.c self_layouter_builtins.c self_layouter_builtins.h self_layouter_default.c self_layouter_default.h self_layouter_menu.c self_layouter_menu.h self_layouter_parser.c
  group awtk/src/lcd
    ../lib/awtk/awtk/src/lcd/: lcd_mem_bgr565.c lcd_mem_bgra8888.c lcd_mem_rgb565.c lcd_mem_rgba8888.c lcd_mono.c lcd_mono.h lcd_nanovg.c lcd_nanovg.h lcd_vgcanvas.inc
  group awtk/src/main_loop
    ../lib/awtk/awtk/src/main_loop/: main_loop_simple.c main_loop_simple.h
  group awtk/src/misc
    ../lib/awtk/awtk/src/misc/: new.cpp new.hpp test_cpp.cpp
  group awtk/src/platforms/ark
    ../lib/awtk/awtk/src/platforms/ark/: fs_os.c platform.c thread_with_pthread.c
  group awtk/src/streams/buffered
    ../lib/awtk/awtk/src/streams/buffered/: istream_buffered.c istream_buffered.h ostream_buffered.c ostream_buffered.h
  group awtk/src/streams/file
    ../lib/awtk/awtk/src/streams/file/: istream_file.c istream_file.h ostream_file.c ostream_file.h
  group awtk/src/streams/mem
    ../lib/awtk/awtk/src/streams/mem/: iostream_mem.c iostream_mem.h istream_mem.c istream_mem.h ostream_mem.c ostream_mem.h
  group awtk/src/streams/misc
    ../lib/awtk/awtk/src/streams/misc/: ostream_retry.c ostream_retry.h
  group awtk/src/streams/noisy
    ../lib/awtk/awtk/src/streams/noisy/: iostream_noisy.c iostream_noisy.h ostream_noisy.c ostream_noisy.h
  group awtk/src/svg
    ../lib/awtk/awtk/src/svg/: bsvg.c bsvg.h bsvg_builder.c bsvg_builder.h bsvg_common.h bsvg_draw.c bsvg_draw.h bsvg_to_svg.c bsvg_to_svg.h svg_path.c svg_path.h svg_path_parser.c svg_path_parser.h svg_shape.c svg_shape.h svg_to_bsvg.c svg_to_bsvg.h
  group awtk/src/tkc
    ../lib/awtk/awtk/src/tkc/: action_queue.c action_queue.h action_thread.c action_thread.h action_thread_pool.c action_thread_pool.h asset_info.c asset_info.h async.c async.h buffer.c buffer.h color.c color.h color_parser.c color_parser.h compressor.c compressor.h cond.h cond_var.c cond_var.h crc.c crc.h darray.c darray.h data_reader.c data_reader.h data_reader_factory.c data_reader_factory.h data_reader_file.c data_reader_file.h data_reader_mem.c data_reader_mem.h data_writer.c data_writer.h data_writer_factory.c data_writer_factory.h data_writer_file.c data_writer_file.h data_writer_wbuffer.c data_writer_wbuffer.h date_time.c date_time.h dl.h easing.c easing.h emitter.c emitter.h endian.h event.c event.h event_source.c event_source.h event_source_fd.c event_source_fd.h event_source_idle.c event_source_idle.h event_source_manager.c event_source_manager.h event_source_manager_default.c event_source_manager_default.h event_source_timer.c event_source_timer.h fs.c fs.h fscript.c fscript.h func_call_parser.c func_call_parser.h func_desc.h idle_info.c idle_info.h idle_manager.c idle_manager.h int_str.c int_str.h iostream.c iostream.h istream.c istream.h line_parser.h log.c log.h matrix.c matrix.h mem.c mem.h mem_allocator.h mem_allocator_debug.h mem_allocator_lock.h mem_allocator_oom.h mem_allocator_pool.h mem_allocator_simple.h mem_allocator_std.h mem_pool.h mime_types.h mmap.h mutex.h mutex_nest.c mutex_nest.h named_value.c named_value.h object.c object.h object_array.c object_array.h object_compositor.c object_compositor.h object_date_time.c object_date_time.h object_default.c object_default.h object_locker.c object_locker.h object_rbuffer.c object_rbuffer.h object_typed_array.c object_typed_array.h object_wbuffer.c object_wbuffer.h ostream.c ostream.h path.c path.h platform.h plugin_manager.c plugin_manager.h qaction.c qaction.h rect.c rect.h ring_buffer.c ring_buffer.h rlog.c rlog.h rom_fs.c rom_fs.h semaphore.h slist.c slist.h socket_helper.c socket_helper.h socket_pair.c socket_pair.h str.c str.h str_str.c str_str.h stream_const.h tck_utils.c thread.h time_now.c time_now.h timer_info.c timer_info.h timer_manager.c timer_manager.h tokenizer.c tokenizer.h typed_array.c typed_array.h types_def.h url.c url.h utf8.c utf8.h utils.h value.c value.h value_desc.c value_desc.h vssver.scc waitable_action_queue.c waitable_action_queue.h waitable_ring_buffer.c waitable_ring_buffer.h wstr.c wstr.h
  group awtk/src/ubjson
    ../lib/awtk/awtk/src/ubjson/: ubjson_const.h ubjson_parser.c ubjson_parser.h ubjson_reader.c ubjson_reader.h ubjson_writer.c ubjson_writer.h
  group awtk/src/ui_loader
    ../lib/awtk/awtk/src/ui_loader/: ui_binary_writer.c ui_binary_writer.h ui_builder_default.c ui_builder_default.h ui_loader_default.c ui_loader_default.h ui_loader_xml.c ui_loader_xml.h ui_serializer.c ui_serializer.h ui_xml_writer.c ui_xml_writer.h window_open.c
  group awtk/src/vgcanvas
    ../lib/awtk/awtk/src/vgcanvas/: vgcanvas_nanovg.inc vgcanvas_null.c
  group awtk/src/widget_animators
    ../lib/awtk/awtk/src/widget_animators/: widget_animator_factory.c widget_animator_move.h widget_animator_opacity.h widget_animator_prop.c widget_animator_prop.h widget_animator_prop2.c widget_animator_prop2.h widget_animator_rotation.h widget_animator_scale.h widget_animator_scroll.c widget_animator_scroll.h widget_animator_value.h
  group awtk/src/widgets
    ../lib/awtk/awtk/src/widgets/: app_bar.c app_bar.h button.c button.h button_group.c button_group.h calibration_win.c calibration_win.h check_button.c check_button.h clip_view.c clip_view.h color_tile.c color_tile.h column.c column.h combo_box.c combo_box.h combo_box_item.c combo_box_item.h dialog_client.c dialog_client.h dialog_helper.c dialog_title.c dialog_title.h digit_clock.c digit_clock.h dragger.c dragger.h edit.c edit.h edit_date.h edit_ipv4.h edit_pattern.h edit_time.h edit_time_full.h grid.c grid.h grid_item.c grid_item.h group_box.c group_box.h image.c image.h label.c label.h overlay.c overlay.h pages.c pages.h popup.c popup.h progress_bar.c progress_bar.h row.c row.h slider.c slider.h spin_box.c spin_box.h system_bar.c system_bar.h tab_button.c tab_button.h tab_button_group.c tab_button_group.h tab_control.c tab_control.h view.c view.h vssver.scc widgets.c widgets.h
  group awtk/src/window_animators
    ../lib/awtk/awtk/src/window_animators/: window_animator_builtins.c window_animator_builtins.h window_animator_center_scale.c window_animator_center_scale.h window_animator_common.c window_animator_common.h window_animator_fade.c window_animator_fade.h window_animator_htranslate.c window_animator_htranslate.h window_animator_popdown.c window_animator_popdown.h window_animator_popup.c window_animator_popup.h window_animator_slide.c window_animator_slide.h window_animator_slide_down.c window_animator_slide_down.h window_animator_slide_left.c window_animator_slide_left.h window_animator_slide_right.c window_animator_slide_right.h window_animator_slide_up.c window_animator_slide_up.h window_animator_vtranslate.c window_animator_vtranslate.h
  group awtk/src/window_manager
    ../lib/awtk/awtk/src/window_manager/: window_manager_default.c window_manager_default.h
  group awtk/src/xml
    ../lib/awtk/awtk/src/xml/: xml_builder.c xml_builder.h xml_parser.c xml_parser.h
