# IAR project vb7018_voice.ewp, settings and files
configuration library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: AMT630HV100
  ICCARM.CCDiagSuppress: Pa050,Pe188,Pa118,Pe111,Pa089
  ICCARM.CCIncludePath2: ..\.; ..\app\vb7018_voice; ..\FreeRTOS\Source\include; ..\FreeRTOS\Source\portable; ..\ArkmicroFiles\libboard-amt630hv100; ..\ArkmicroFiles\libboard-amt630hv100\include; ..\ArkmicroFiles\libcpu-amt630hv100; ..\ArkmicroFiles\libcpu-amt630hv100\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: vb7018_voice.out
  group vb7018_voice
    ../app/vb7018_voice/: vb7018_voice.c vb7018_voice.h
