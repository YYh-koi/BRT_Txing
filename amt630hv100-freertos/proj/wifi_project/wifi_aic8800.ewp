# IAR project wifi_aic8800.ewp, settings and files
configuration library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: AMT630HV100; FREERTOS=1; __RTOS_FREERTOS__; CARLINK_ENABLE; CHIPSET_SUPPORT_AIC8800D80
  ICCARM.CCIncludePath2: ..\..\.; ..\..\FreeRTOS\Source\include; ..\..\FreeRTOS\Source\portable; ..\..\demo\common\include; ..\..\ArkmicroFiles\libboard-amt630hv100; ..\..\ArkmicroFiles\libboard-amt630hv100\include; ..\..\ArkmicroFiles\libcpu-amt630hv100; ..\..\ArkmicroFiles\libcpu-amt630hv100\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\..\lib\wlan\; ..\..\lib\lwip\src\include\; ..\..\lib\lwip\src\include\lwip\; ..\..\lib\lwip\src\include\arch\; ..\..\lib\lwip\src\include\compat\; ..\..\lib\lwip\src\include\compat\posix\; ..\..\lib\lwip\src\include\netif\; ..\..\lib\wlan\aic8800
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AndroidAuto.srec
  ILINK.IlinkOutputFile: AndroidAuto.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group aic8800
    ../../lib/wlan/aic8800/: ethernetwlanif.c iot_wifi_aic8800.c
