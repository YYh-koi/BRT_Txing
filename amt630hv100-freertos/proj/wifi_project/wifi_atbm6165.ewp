# IAR project wifi_atbm6165.ewp, settings and files
configuration library (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: AMT630HV100; FREERTOS=1; __RTOS_FREERTOS__; CARLINK_ENABLE
  ICCARM.CCIncludePath2: ..\..\.; ..\..\FreeRTOS\Source\include; ..\..\FreeRTOS\Source\portable; ..\..\demo\common\include; ..\..\ArkmicroFiles\libboard-amt630hv100; ..\..\ArkmicroFiles\libboard-amt630hv100\include; ..\..\ArkmicroFiles\libcpu-amt630hv100; ..\..\ArkmicroFiles\libcpu-amt630hv100\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\..\lib\wlan\; ..\..\lib\lwip\src\include\; ..\..\lib\lwip\src\include\lwip\; ..\..\lib\lwip\src\include\arch\; ..\..\lib\lwip\src\include\compat\; ..\..\lib\lwip\src\include\netif\; ..\..\lib\wlan\atbm_wifi6\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: wifi_atbm6165.out
  group atbm6165
    ../../lib/wlan/atbm_wifi6/: ethernetwlanif.c iot_wifi_atbm6165.c
