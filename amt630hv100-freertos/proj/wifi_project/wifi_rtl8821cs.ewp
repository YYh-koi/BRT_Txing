# IAR project wifi_rtl8821cs.ewp, settings and files
configuration library (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: AMT630HV100; FREERTOS=1; __RTOS_FREERTOS__; CARLINK_ENABLE
  ICCARM.CCIncludePath2: ..\..\.; ..\..\FreeRTOS\Source\include; ..\..\FreeRTOS\Source\portable; ..\..\demo\common\include; ..\..\ArkmicroFiles\libboard-amt630hv100; ..\..\ArkmicroFiles\libboard-amt630hv100\include; ..\..\ArkmicroFiles\libcpu-amt630hv100; ..\..\ArkmicroFiles\libcpu-amt630hv100\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-CLI; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\FreeRTOS-Plus-POSIX\include\portable; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\private; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-POSIX\include\FreeRTOS_POSIX; ..\..\lib\wlan\rtl8821cs\api; ..\..\lib\wlan\rtl8821cs\api\wifi; ..\..\lib\wlan\rtl8821cs\include; ..\..\lib\wlan\rtl8821cs\os\customer_rtos; ..\..\lib\wlan\rtl8821cs\os\os_dep\include; ..\..\lib\wlan\rtl8821cs\platform\include; ..\..\lib\wlan\rtl8821cs\platform\rtwlan_bsp; ..\..\lib\wlan\rtl8821cs\platform\sdio; ..\..\lib\wlan\rtl8821cs\platform\sdio\include; ..\..\lib\wlan\rtl8821cs\platform\sdio\core; ..\..\lib\wlan\rtl8821cs\api\wifi\rtw_wpa_supplicant\wpa_supplicant\; ..\..\lib\wlan\rtl8821cs\api\wifi\rtw_wpa_supplicant\src; ..\..\lib\wlan\rtl8821cs\api\wifi\rtw_wpa_supplicant\src\utils; ..\..\lib\wlan\rtl8821cs\api\wifi\rtw_wpa_supplicant\src\utils\rom\; ..\..\lib\wlan\rtl8821cs\api\wifi\rtw_wpa_supplicant\src\wps\; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\include\; ..\..\FreeRTOS-Plus\FreeRTOS-Plus-TCP\portable\Compiler\IAR\; ..\..\lib\wlan\; ..\..\lib\lwip\src\include\; ..\..\lib\lwip\src\include\lwip\; ..\..\lib\lwip\src\include\arch\; ..\..\lib\lwip\src\include\compat\; ..\..\lib\lwip\src\include\netif\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AndroidAuto.srec
  ILINK.IlinkOutputFile: AndroidAuto.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../lib/wlan/rtl8821cs/: iot_wifi_rtl8821cs.c
  group rtl8821cs
    ../../lib/wlan/rtl8821cs/: ethernetwlanif.c
  group rtl8821cs/api
    ../../lib/wlan/rtl8821cs/api/: wifi_interactive_mode.c
  group rtl8821cs/api/wifi
    ../../lib/wlan/rtl8821cs/api/wifi/: wifi_conf.c wifi_ind.c wifi_promisc.c wifi_util.c
  group rtl8821cs/api/wifi/rtw_wpa_supplicant/wpa_supplicant
    ../../lib/wlan/rtl8821cs/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_p2p_config.c wifi_wps_config.c
  group rtl8821cs/os/customer_rtos
    ../../lib/wlan/rtl8821cs/os/customer_rtos/: customer_rtos_service.c
  group rtl8821cs/os/os_dep
    ../../lib/wlan/rtl8821cs/os/os_dep/: device_lock.c net_stack_intf.c osdep_service.c
  group rtl8821cs/platform/rtwlan_bsp
    ../../lib/wlan/rtl8821cs/platform/rtwlan_bsp/: rtwlan_bsp.c
  group rtl8821cs/platform/sdio
    ../../lib/wlan/rtl8821cs/platform/sdio/: wifi_io.c
